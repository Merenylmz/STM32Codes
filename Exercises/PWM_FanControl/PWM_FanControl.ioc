# file: PWM_FanControl.ioc
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Mcu.Family=STM32F4
Mcu.Name=STM32F407V(E-G)Tx
Mcu.Package=LQFP100
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.48MHZClocksFreq_Value=84000000
RCC.AHBFreq_Value=168000000
RCC.APB1CLKDivider=RCC_HCLK_DIV4
RCC.APB1Freq_Value=42000000
RCC.APB1TimFreq_Value=84000000
RCC.APB2CLKDivider=RCC_HCLK_DIV2
RCC.APB2Freq_Value=84000000
RCC.APB2TimFreq_Value=168000000
RCC.CortexFreq_Value=168000000
RCC.HCLKFreq_Value=168000000
RCC.HSE_VALUE=25000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.PLLM=8
RCC.PLLN=168
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.VCOOutputFreq_Value=336000000
board=custom

// file: Core/Src/main.c
#include "main.h"
void SystemClock_Config(void);

volatile uint32_t adcValue, ccrValue;
volatile short i = 1;
volatile uint8_t fadeMode = 0;
volatile int fadeValue = 0;
volatile int fadeDirection = 1;

void RCC_Config(){
	RCC->CR |= 0x01010000;
	while(!(RCC->CR & RCC_CR_HSERDY));

	FLASH->ACR |= 0x00000005; // işlemci hızlamadan önce bir gecikme verir.

	RCC->PLLCFGR = 0x07405408;
	RCC->CR |= (1 << 24); // PLLON
	while(!(RCC->CR & RCC_CR_PLLRDY));

	RCC->CFGR |= 0x0000940A;
	while ((RCC->CFGR & RCC_CFGR_SWS) != RCC_CFGR_SWS_PLL);
}

void GPIO_Config(){
	RCC->AHB1ENR |= 0x00000009;

	GPIOD->MODER &= ~(3 << 24);
	GPIOD->MODER |= 2 << 24;

	GPIOD->AFR[1] &= ~(0xF << 16);
	GPIOD->AFR[1] |= (0x2 << 16);

	GPIOA->MODER |= 3 << 0;

	//For The Hz Button
	GPIOA->MODER &= ~(3 << 2);
	GPIOA->PUPDR &= ~(3 << 2);
	GPIOA->PUPDR |= 2 << 2;

	//For The Fade Effect Button
	GPIOA->MODER &= ~(3 << 4);
	GPIOA->PUPDR &= ~(3 << 4);
	GPIOA->PUPDR |= 2 << 4;

}

void TIM4_Config(){
	RCC->APB1ENR |= 0x00000004;

	TIM4->PSC = 83;
	TIM4->ARR = 999;
	TIM4->CCMR1 |= (6 << 4);
	TIM4->CCMR1 |= (1 << 3);
	TIM4->CCER |= 1 << 0 | 1 << 4 | 1 << 8 | 1 << 12;

	TIM4->CCR1 = 999; // baslangic degeri

	TIM4->EGR |= 1 << 0;
	TIM4->CR1 |= 1 << 0;
}

void TIM2_Config(){
	RCC->APB1ENR |= (1 << 0);

	TIM2->PSC = 8399;
	TIM2->ARR = 99;

	TIM2->DIER |= (1 << 0);
	NVIC_EnableIRQ(TIM2_IRQn);

	TIM2->CR1 |= (1 << 0);
}

void ADC_Config(){
	RCC->APB2ENR |= 1 << 8;

	ADC->CCR |= 1 << 16;

	ADC1->SQR3 &= ~(0x1F << 0);

	ADC1->CR2 |= 1 << 1;
	ADC1->CR2 |= 1 << 0;
	ADC1->CR2 |= 1 << 30;
}

uint32_t readADC(){
	while(!(ADC1->SR & (1 << 1)));

	return (uint32_t)ADC1->DR;
}

void delay(uint16_t delay){
	for(volatile int k = 0; k < delay; k++);
}

void updatePWMFrequency(int val){
	TIM4->PSC = val;
}

void TIM2_IRQHandler(){
	if (fadeMode == 1) {
		if (fadeDirection == 1) {
			fadeValue += 10;
			if (fadeValue >= 999) {
				fadeValue = 999;
				fadeDirection = 0;
			}
		}
		else {
			fadeValue -= 10;
			if (fadeValue <= 0) {
				fadeValue = 0;
				fadeDirection = 1;
			}
		}

		TIM4->CCR1 = fadeValue;
	}
	TIM2->SR &= ~(1 << 0);
}

int main(void)
{

  //HAL_Init();
  //SystemClock_Config();

	RCC_Config();
	GPIO_Config();
	TIM4_Config();
	TIM2_Config();
	ADC_Config();

  while (1)
  {
	  if (GPIOA->IDR & (1 << 1)) {
		  delay(50000);
		  if (GPIOA->IDR & (1 << 1)) {
		  ++i;
		  switch (i) {
			case 1: updatePWMFrequency(167); break;
			case 2: updatePWMFrequency(83); break;
			case 3: updatePWMFrequency(41); i = 0; break;
			default:
				updatePWMFrequency(83);
				break;
		}
		  while (GPIOA->IDR & (1 << 1));
		 delay(60000);
	  }
	}
	  if (GPIOA->IDR & (1 << 2)) {
		  delay(50000);
		  if (GPIOA->IDR & (1 << 2)) {

			  if (fadeMode == 0) {fadeMode=1;}
			  else {fadeMode = 0;}

			  while (GPIOA->IDR & (1 << 2));
			 delay(60000);
		  }
	}

	  if (fadeMode == 0) {
		  adcValue = readADC();
		  ccrValue = (adcValue*999)/4095;
		  TIM4->CCR1 = ccrValue;
	}

	  delay(50000);
  }

}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** Configure the main internal regulator output voltage
  */
  __HAL_RCC_PWR_CLK_ENABLE();
  __HAL_PWR_VOLTAGESCALING_CONFIG(PWR_REGULATOR_VOLTAGE_SCALE1);

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_0) != HAL_OK)
  {
    Error_Handler();
  }
}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
